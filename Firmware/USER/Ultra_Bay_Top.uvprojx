# Keil uVision project Ultra_Bay_Top.uvprojx, settings and files
target Ultra_Bay_Top (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Ultra_Bay_Top +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\FWLIB\inc;..\HARDWARE;..\USB;..\USB\USB_Device\inc;..\USB\USB_OTG\inc;..\USB_APP;..\USB_APP\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c STM32F407VET_Config.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_usart.c
  group README
    ../: readme.txt
  group USB
    ../USB/USB_Device/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/USB_OTG/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_bsp.c
  group USB_APP
    ../USB_APP/src/: usbd_cdc_core.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
